#include "oled.h"
#include "ti_msp_dl_config.h"
#include <string.h>
#include <stdarg.h>
#include <stdio.h>

#define OLED_ADDR  0x3C
#define CMD_BYTE   0x00
#define DATA_BYTE  0x40

typedef enum { I2C_IDLE=0, I2C_BUSY, I2C_DONE, I2C_ERR } I2cSt;
static volatile I2cSt      gSt;
static const uint8_t      *gBuf;
static volatile uint16_t   gLen, gIdx;

static uint8_t gFb[OLED_PAGES][OLED_WIDTH];
static uint8_t gDirty;
static uint8_t gCol, gPage;

static const uint8_t gFont[95][8] = {
{0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, /* ' ' */
{0x00,0x00,0x5F,0x00,0x00,0x00,0x00,0x00}, /* ! */
{0x00,0x07,0x00,0x07,0x00,0x00,0x00,0x00}, /* " */
{0x14,0x7F,0x14,0x7F,0x14,0x00,0x00,0x00}, /* # */
{0x24,0x2A,0x7F,0x2A,0x12,0x00,0x00,0x00}, /* $ */
{0x23,0x13,0x08,0x64,0x62,0x00,0x00,0x00}, /* % */
{0x36,0x49,0x55,0x22,0x50,0x00,0x00,0x00}, /* & */
{0x00,0x05,0x03,0x00,0x00,0x00,0x00,0x00}, /* ' */
{0x00,0x1C,0x22,0x41,0x00,0x00,0x00,0x00}, /* ( */
{0x00,0x41,0x22,0x1C,0x00,0x00,0x00,0x00}, /* ) */
{0x08,0x2A,0x1C,0x2A,0x08,0x00,0x00,0x00}, /* * */
{0x08,0x08,0x3E,0x08,0x08,0x00,0x00,0x00}, /* + */
{0x00,0x50,0x30,0x00,0x00,0x00,0x00,0x00}, /* , */
{0x08,0x08,0x08,0x08,0x08,0x00,0x00,0x00}, /* - */
{0x00,0x60,0x60,0x00,0x00,0x00,0x00,0x00}, /* . */
{0x20,0x10,0x08,0x04,0x02,0x00,0x00,0x00}, /* / */
{0x3E,0x51,0x49,0x45,0x3E,0x00,0x00,0x00}, /* 0 */
{0x00,0x42,0x7F,0x40,0x00,0x00,0x00,0x00}, /* 1 */
{0x42,0x61,0x51,0x49,0x46,0x00,0x00,0x00}, /* 2 */
{0x21,0x41,0x45,0x4B,0x31,0x00,0x00,0x00}, /* 3 */
{0x18,0x14,0x12,0x7F,0x10,0x00,0x00,0x00}, /* 4 */
{0x27,0x45,0x45,0x45,0x39,0x00,0x00,0x00}, /* 5 */
{0x3C,0x4A,0x49,0x49,0x30,0x00,0x00,0x00}, /* 6 */
{0x01,0x71,0x09,0x05,0x03,0x00,0x00,0x00}, /* 7 */
{0x36,0x49,0x49,0x49,0x36,0x00,0x00,0x00}, /* 8 */
{0x06,0x49,0x49,0x29,0x1E,0x00,0x00,0x00}, /* 9 */
{0x00,0x36,0x36,0x00,0x00,0x00,0x00,0x00}, /* : */
{0x00,0x56,0x36,0x00,0x00,0x00,0x00,0x00}, /* ; */
{0x00,0x08,0x14,0x22,0x41,0x00,0x00,0x00}, /* < */
{0x14,0x14,0x14,0x14,0x14,0x00,0x00,0x00}, /* = */
{0x41,0x22,0x14,0x08,0x00,0x00,0x00,0x00}, /* > */
{0x02,0x01,0x51,0x09,0x06,0x00,0x00,0x00}, /* ? */
{0x32,0x49,0x79,0x41,0x3E,0x00,0x00,0x00}, /* @ */
{0x7E,0x11,0x11,0x11,0x7E,0x00,0x00,0x00}, /* A */
{0x7F,0x49,0x49,0x49,0x36,0x00,0x00,0x00}, /* B */
{0x3E,0x41,0x41,0x41,0x22,0x00,0x00,0x00}, /* C */
{0x7F,0x41,0x41,0x22,0x1C,0x00,0x00,0x00}, /* D */
{0x7F,0x49,0x49,0x49,0x41,0x00,0x00,0x00}, /* E */
{0x7F,0x09,0x09,0x01,0x01,0x00,0x00,0x00}, /* F */
{0x3E,0x41,0x41,0x51,0x32,0x00,0x00,0x00}, /* G */
{0x7F,0x08,0x08,0x08,0x7F,0x00,0x00,0x00}, /* H */
{0x00,0x41,0x7F,0x41,0x00,0x00,0x00,0x00}, /* I */
{0x20,0x40,0x41,0x3F,0x01,0x00,0x00,0x00}, /* J */
{0x7F,0x08,0x14,0x22,0x41,0x00,0x00,0x00}, /* K */
{0x7F,0x40,0x40,0x40,0x40,0x00,0x00,0x00}, /* L */
{0x7F,0x02,0x04,0x02,0x7F,0x00,0x00,0x00}, /* M */
{0x7F,0x04,0x08,0x10,0x7F,0x00,0x00,0x00}, /* N */
{0x3E,0x41,0x41,0x41,0x3E,0x00,0x00,0x00}, /* O */
{0x7F,0x09,0x09,0x09,0x06,0x00,0x00,0x00}, /* P */
{0x3E,0x41,0x51,0x21,0x5E,0x00,0x00,0x00}, /* Q */
{0x7F,0x09,0x19,0x29,0x46,0x00,0x00,0x00}, /* R */
{0x46,0x49,0x49,0x49,0x31,0x00,0x00,0x00}, /* S */
{0x01,0x01,0x7F,0x01,0x01,0x00,0x00,0x00}, /* T */
{0x3F,0x40,0x40,0x40,0x3F,0x00,0x00,0x00}, /* U */
{0x1F,0x20,0x40,0x20,0x1F,0x00,0x00,0x00}, /* V */
{0x7F,0x20,0x18,0x20,0x7F,0x00,0x00,0x00}, /* W */
{0x63,0x14,0x08,0x14,0x63,0x00,0x00,0x00}, /* X */
{0x03,0x04,0x78,0x04,0x03,0x00,0x00,0x00}, /* Y */
{0x61,0x51,0x49,0x45,0x43,0x00,0x00,0x00}, /* Z */
{0x00,0x00,0x7F,0x41,0x41,0x00,0x00,0x00}, /* [ */
{0x02,0x04,0x08,0x10,0x20,0x00,0x00,0x00}, /* \ */
{0x41,0x41,0x7F,0x00,0x00,0x00,0x00,0x00}, /* ] */
{0x04,0x02,0x01,0x02,0x04,0x00,0x00,0x00}, /* ^ */
{0x40,0x40,0x40,0x40,0x40,0x00,0x00,0x00}, /* _ */
{0x00,0x01,0x02,0x04,0x00,0x00,0x00,0x00}, /* ` */
{0x20,0x54,0x54,0x54,0x78,0x00,0x00,0x00}, /* a */
{0x7F,0x48,0x44,0x44,0x38,0x00,0x00,0x00}, /* b */
{0x38,0x44,0x44,0x44,0x20,0x00,0x00,0x00}, /* c */
{0x38,0x44,0x44,0x48,0x7F,0x00,0x00,0x00}, /* d */
{0x38,0x54,0x54,0x54,0x18,0x00,0x00,0x00}, /* e */
{0x08,0x7E,0x09,0x01,0x02,0x00,0x00,0x00}, /* f */
{0x08,0x54,0x54,0x54,0x3C,0x00,0x00,0x00}, /* g */
{0x7F,0x08,0x04,0x04,0x78,0x00,0x00,0x00}, /* h */
{0x00,0x44,0x7D,0x40,0x00,0x00,0x00,0x00}, /* i */
{0x20,0x40,0x44,0x3D,0x00,0x00,0x00,0x00}, /* j */
{0x00,0x7F,0x10,0x28,0x44,0x00,0x00,0x00}, /* k */
{0x00,0x41,0x7F,0x40,0x00,0x00,0x00,0x00}, /* l */
{0x7C,0x04,0x18,0x04,0x78,0x00,0x00,0x00}, /* m */
{0x7C,0x08,0x04,0x04,0x78,0x00,0x00,0x00}, /* n */
{0x38,0x44,0x44,0x44,0x38,0x00,0x00,0x00}, /* o */
{0x7C,0x14,0x14,0x14,0x08,0x00,0x00,0x00}, /* p */
{0x08,0x14,0x14,0x18,0x7C,0x00,0x00,0x00}, /* q */
{0x7C,0x08,0x04,0x04,0x08,0x00,0x00,0x00}, /* r */
{0x48,0x54,0x54,0x54,0x20,0x00,0x00,0x00}, /* s */
{0x04,0x3F,0x44,0x40,0x20,0x00,0x00,0x00}, /* t */
{0x3C,0x40,0x40,0x20,0x7C,0x00,0x00,0x00}, /* u */
{0x1C,0x20,0x40,0x20,0x1C,0x00,0x00,0x00}, /* v */
{0x3C,0x40,0x30,0x40,0x3C,0x00,0x00,0x00}, /* w */
{0x44,0x28,0x10,0x28,0x44,0x00,0x00,0x00}, /* x */
{0x0C,0x50,0x50,0x50,0x3C,0x00,0x00,0x00}, /* y */
{0x44,0x64,0x54,0x4C,0x44,0x00,0x00,0x00}, /* z */
{0x00,0x08,0x36,0x41,0x00,0x00,0x00,0x00}, /* { */
{0x00,0x00,0x7F,0x00,0x00,0x00,0x00,0x00}, /* | */
{0x00,0x41,0x36,0x08,0x00,0x00,0x00,0x00}, /* } */
{0x08,0x08,0x2A,0x1C,0x08,0x00,0x00,0x00}, /* ~ */
};

static void i2c_send(const uint8_t *buf, uint16_t len)
{
    gBuf = buf;
    gLen = len;
    gIdx = DL_I2C_fillControllerTXFIFO(I2C_0_INST, (uint8_t *)buf, len);
    if (gIdx < len)
        DL_I2C_enableInterrupt(I2C_0_INST, DL_I2C_INTERRUPT_CONTROLLER_TXFIFO_TRIGGER);
    else
        DL_I2C_disableInterrupt(I2C_0_INST, DL_I2C_INTERRUPT_CONTROLLER_TXFIFO_TRIGGER);
    gSt = I2C_BUSY;
    while (!(DL_I2C_getControllerStatus(I2C_0_INST) & DL_I2C_CONTROLLER_STATUS_IDLE));
    DL_I2C_startControllerTransfer(I2C_0_INST, OLED_ADDR, DL_I2C_CONTROLLER_DIRECTION_TX, len);
    while (gSt == I2C_BUSY) __WFE();
    while (DL_I2C_getControllerStatus(I2C_0_INST) & DL_I2C_CONTROLLER_STATUS_BUSY_BUS);
}

void I2C_0_INST_IRQHandler(void)
{
    switch (DL_I2C_getPendingInterrupt(I2C_0_INST)) {
        case DL_I2C_IIDX_CONTROLLER_TX_DONE:
            DL_I2C_disableInterrupt(I2C_0_INST, DL_I2C_INTERRUPT_CONTROLLER_TXFIFO_TRIGGER);
            gSt = I2C_DONE;
            break;
        case DL_I2C_IIDX_CONTROLLER_TXFIFO_TRIGGER:
            if (gIdx < gLen)
                gIdx += DL_I2C_fillControllerTXFIFO(I2C_0_INST, (uint8_t *)&gBuf[gIdx], gLen - gIdx);
            break;
        case DL_I2C_IIDX_CONTROLLER_NACK:
        case DL_I2C_IIDX_CONTROLLER_ARBITRATION_LOST:
            gSt = I2C_ERR;
            break;
        default: break;
    }
}

static const uint8_t gInitSeq[] = {
    CMD_BYTE,
    0xAE, 0x20,0x00, 0xB0, 0xC8, 0x00, 0x10, 0x40,
    0x81,0xFF, 0xA1, 0xA6, 0xA8,0x3F, 0xA4,
    0xD3,0x00, 0xD5,0xF0, 0xD9,0x22, 0xDA,0x12, 0xDB,0x20,
    0x8D,0x14, 0xAF
};

void OLED_init(void)
{
    NVIC_EnableIRQ(I2C_0_INST_INT_IRQN);
    gSt = I2C_IDLE;
    memset(gFb, 0, sizeof(gFb));
    gDirty = 0xFF;
    gCol = 0; gPage = 0;
    delay_cycles(320000);
    i2c_send(gInitSeq, sizeof(gInitSeq));
}

void OLED_clear(void)
{
    memset(gFb, 0, sizeof(gFb));
    gDirty = 0xFF;
}

void OLED_markDirty(void) { gDirty = 0xFF; }

void OLED_display(void)
{
    static uint8_t buf[1 + OLED_WIDTH];
    buf[0] = DATA_BYTE;
    for (uint8_t p = 0; p < OLED_PAGES; p++) {
        if (!(gDirty & (1u << p))) continue;
        uint8_t addr[7] = {CMD_BYTE, 0x21,0x00,0x7F, 0x22,p,p};
        i2c_send(addr, 7);
        memcpy(&buf[1], gFb[p], OLED_WIDTH);
        i2c_send(buf, 1 + OLED_WIDTH);
        gDirty &= ~(1u << p);
    }
}

void OLED_setPixel(uint8_t x, uint8_t y, bool on)
{
    if (x >= OLED_WIDTH || y >= OLED_HEIGHT) return;
    uint8_t page = y >> 3, bit = y & 7;
    if (on) gFb[page][x] |=  (1u << bit);
    else    gFb[page][x] &= ~(1u << bit);
    gDirty |= (1u << page);
}

bool OLED_getPixel(uint8_t x, uint8_t y)
{
    if (x >= OLED_WIDTH || y >= OLED_HEIGHT) return false;
    return (gFb[y >> 3][x] >> (y & 7)) & 1;
}

void OLED_drawLine(uint8_t x0, uint8_t y0, uint8_t x1, uint8_t y1, bool on)
{
    int16_t dx = (x1>x0)?(x1-x0):(x0-x1), dy = (y1>y0)?(y1-y0):(y0-y1);
    int16_t sx = (x0<x1)?1:-1,             sy = (y0<y1)?1:-1;
    int16_t err = dx - dy, cx = x0, cy = y0;
    while (1) {
        OLED_setPixel((uint8_t)cx,(uint8_t)cy,on);
        if (cx==x1 && cy==y1) break;
        int16_t e2 = 2*err;
        if (e2 > -dy) { err -= dy; cx += sx; }
        if (e2 <  dx) { err += dx; cy += sy; }
    }
}

void OLED_drawRect(uint8_t x, uint8_t y, uint8_t w, uint8_t h, bool on)
{
    if (!w || !h) return;
    uint8_t x1=x+w-1, y1=y+h-1;
    OLED_drawLine(x,y,x1,y,on); OLED_drawLine(x,y1,x1,y1,on);
    OLED_drawLine(x,y,x,y1,on); OLED_drawLine(x1,y,x1,y1,on);
}

void OLED_fillRect(uint8_t x, uint8_t y, uint8_t w, uint8_t h, bool on)
{
    if (!w || !h || x>=OLED_WIDTH || y>=OLED_HEIGHT) return;
    uint8_t xe = (x+w > OLED_WIDTH)  ? OLED_WIDTH  : x+w;
    uint8_t ye = (y+h > OLED_HEIGHT) ? OLED_HEIGHT : y+h;
    uint8_t p0 = y>>3, p1 = (ye-1)>>3;
    for (uint8_t p = p0; p <= p1; p++) {
        uint8_t mask;
        if (p0==p1) {
            mask = ((1u<<(ye-y))-1u) << (y&7);
        } else if (p==p0) {
            mask = 0xFF << (y&7);
        } else if (p==p1) {
            mask = (1u<<((ye-1&7)+1))-1u;
        } else {
            mask = 0xFF;
        }
        for (uint8_t col=x; col<xe; col++) {
            if (on) gFb[p][col] |=  mask;
            else    gFb[p][col] &= ~mask;
        }
        gDirty |= (1u<<p);
    }
}

void OLED_drawCircle(uint8_t cx, uint8_t cy, uint8_t r, bool on)
{
    int16_t x = 0, y = r, d = 1 - r;
    while (x <= y) {
        OLED_setPixel(cx+x,cy+y,on); OLED_setPixel(cx-x,cy+y,on);
        OLED_setPixel(cx+x,cy-y,on); OLED_setPixel(cx-x,cy-y,on);
        OLED_setPixel(cx+y,cy+x,on); OLED_setPixel(cx-y,cy+x,on);
        OLED_setPixel(cx+y,cy-x,on); OLED_setPixel(cx-y,cy-x,on);
        if (d < 0) d += 2*x+3; else { d += 2*(x-y)+5; y--; }
        x++;
    }
}

void OLED_fillCircle(uint8_t cx, uint8_t cy, uint8_t r, bool on)
{
    int16_t x = 0, y = r, d = 1 - r;
    while (x <= y) {
        OLED_fillRect((uint8_t)(cx-x),(uint8_t)(cy-y),(uint8_t)(2*x+1),1,on);
        OLED_fillRect((uint8_t)(cx-x),(uint8_t)(cy+y),(uint8_t)(2*x+1),1,on);
        OLED_fillRect((uint8_t)(cx-y),(uint8_t)(cy-x),(uint8_t)(2*y+1),1,on);
        OLED_fillRect((uint8_t)(cx-y),(uint8_t)(cy+x),(uint8_t)(2*y+1),1,on);
        if (d < 0) d += 2*x+3; else { d += 2*(x-y)+5; y--; }
        x++;
    }
}

void OLED_drawBitmap(uint8_t x, uint8_t y, uint8_t w, uint8_t h,
                     const uint8_t *bmp)
{
    uint8_t pages = (h + 7) >> 3;
    for (uint8_t p = 0; p < pages; p++) {
        uint8_t dp = (y >> 3) + p;
        if (dp >= OLED_PAGES) break;
        uint8_t shift = y & 7;
        for (uint8_t col = 0; col < w; col++) {
            uint8_t dx = x + col;
            if (dx >= OLED_WIDTH) break;
            uint8_t byte = bmp[p * w + col];
            gFb[dp][dx]   |= byte << shift;
            if (shift && dp+1 < OLED_PAGES)
                gFb[dp+1][dx] |= byte >> (8 - shift);
        }
        gDirty |= (1u << dp);
        if (shift && dp+1 < OLED_PAGES) gDirty |= (1u << (dp+1));
    }
}

void OLED_setCursor(uint8_t col, uint8_t page)
{
    gCol  = (col  < OLED_WIDTH/8)  ? col  : 0;
    gPage = (page < OLED_PAGES)    ? page : 0;
}

void OLED_writeChar(char c)
{
    if (c == '\n') { gCol = 0; gPage = (gPage+1) % OLED_PAGES; return; }
    if (c == '\r') { gCol = 0; return; }
    if (c < 0x20 || c > 0x7E) c = '?';
    const uint8_t *g = gFont[(uint8_t)(c - 0x20)];
    uint8_t base = gCol * 8;
    for (uint8_t i = 0; i < 8 && base+i < OLED_WIDTH; i++)
        gFb[gPage][base+i] = g[i];
    gDirty |= (1u << gPage);
    if (++gCol >= OLED_WIDTH/8) { gCol = 0; gPage = (gPage+1) % OLED_PAGES; }
}

void OLED_writeString(const char *str)
{
    while (*str) OLED_writeChar(*str++);
}

void OLED_printf(const char *fmt, ...)
{
    char buf[64];
    va_list ap;
    va_start(ap, fmt);
    vsnprintf(buf, sizeof(buf), fmt, ap);
    va_end(ap);
    OLED_writeString(buf);
}
