# Keil uVision project ncontroller.uvprojx, settings and files
target ncontroller (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ncontroller +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __MSPM0G3507__,ARM_MATH_CM0
  c include: ..\source\third_party\CMSIS\Core\Include;..\source;..\;..\user;..\Algorithm;..\dsplib;..\HardwareDriver;..\FunctionalModule;..\ApplicationLayer
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group sources
    ../source/ti/driverlib/: dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_i2c.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc_common.c dl_spi.c dl_timer.c dl_trng.c dl_uart.c dl_vref.c
    ../source/ti/driverlib/m0p/: dl_interrupt.c
    ../source/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0g1x0x_g3x0x.c
    ../source/ti/devices/msp/m0p/startup_system_files/keil/: startup_mspm0g350x_uvision.s
  group user
    ../user/: main.c datatype.h headfile.h
    ../: ncontroller.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
  group dsplib
    ../dsplib/: arm_cortexM0l_math.a
  group Algorithm
    ../Algorithm/: kalman_filter.c mahony_filter.c pid.c QuaternionEKF.c
  group HardwareDrvier
    ../HardwareDriver/: BMI088Middleware.c EncoderExti.c IIC.c MyMath.c Pwm.c System.c Timer.c Uart.c
  group FunctionalModule
    ../FunctionalModule/: BMI088driver.c Buzzer.c Encoder.c GraySensor.c MotorsCtrl.c Oled.c Key.c Key.h
  group ApplicationLayer
    ../ApplicationLayer/: Task.c
